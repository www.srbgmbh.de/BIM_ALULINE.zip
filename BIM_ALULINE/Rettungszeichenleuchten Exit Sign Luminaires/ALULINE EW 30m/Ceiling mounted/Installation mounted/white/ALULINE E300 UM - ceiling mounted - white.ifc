Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 2018_01
Time: 2022-03-14T13:43:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternativ-UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 14 13:43:47 2022 * Database version: 5507 * Database creation date: Mon Mar 14 13:43:46 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 14 13:43:47 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 14 13:43:47 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: ALULINE E300 UM - ceiling mounted - white:ALULINE E300 UM, ALULINE E300 UM - ceiling mounted - white:ALULINE E300 UM:2475226
In: Default
Type - Material: Kunststoff - PMMA, Kunststoff -PVC, Aluminium Druckguss - RAL9016, RAL 9016
Type - Pset_ElementShading - Color: white
Material: RAL 9016
Pset_DistributionFlowElementCommon - Reference: ALULINE E300 UM; sets with these values: 2
