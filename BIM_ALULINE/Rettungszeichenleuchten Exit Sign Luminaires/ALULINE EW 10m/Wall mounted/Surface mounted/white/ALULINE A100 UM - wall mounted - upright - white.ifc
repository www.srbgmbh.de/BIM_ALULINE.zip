Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 2018_01
Time: 2022-03-09T12:18:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternativ-UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 09 12:18:32 2022 * Database version: 5507 * Database creation date: Wed Mar 09 12:18:32 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 09 12:18:32 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 09 12:18:32 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: ALULINE A100 UM - wall mounted - upright - white:ALULINE A100 UM, ALULINE A100 UM - wall mounted - upright - white:ALULINE A100 UM:2475227
In: Default
Type - Material: Aluminium Druckguss - RAL9016, Kunststoff - PMMA, Kunststoff -PVC, Vorgabe
Type - Pset_ElementShading - Color: white
Type - Pset_ManufacturerTypeInformation - Manufacturer: EMERGENCY LIGHTING
Material: Vorgabe
Pset_DistributionFlowElementCommon - Reference: ALULINE A100 UM; sets with these values: 2
